<?xml version="1.0" encoding="iso-8859-1"?>

<project>
  <fileVersion>2</fileVersion>
  <configuration>
    <name>Debug</name>
    <toolchain>
      <name>MSP430</name>
    </toolchain>
    <debug>1</debug>
  </configuration>
  <configuration>
    <name>Release</name>
    <toolchain>
      <name>MSP430</name>
    </toolchain>
    <debug>0</debug>
  </configuration>
  <file>
    <name>$PROJ_DIR$\BusRead.asm</name>
  </file>
  <file>
    <name>$PROJ_DIR$\BusWrite.asm</name>
  </file>
  <file>
    <name>$PROJ_DIR$\Initialise.asm</name>
  </file>
  <file>
    <name>$PROJ_DIR$\lift1lib.c</name>
  </file>
  <file>
    <name>$PROJ_DIR$\lift1lib.h</name>
  </file>
  <file>
    <name>$PROJ_DIR$\main.c</name>
  </file>
</project>


